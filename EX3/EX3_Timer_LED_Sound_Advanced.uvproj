# Keil uVision project EX3_Timer_LED_Sound_Advanced.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89E554RC SST
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) CLOCK(40000000)
  output: EX3_Timer_LED_Sound_Advanced +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: EX3_Timer_LED_Sound_Advanced.c
