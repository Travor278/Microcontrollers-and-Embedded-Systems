# Keil uVision project Asm2_2.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89E554RC SST
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) CLOCK(40000000)
  output: Asm2_2
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Asm2-2.asm
