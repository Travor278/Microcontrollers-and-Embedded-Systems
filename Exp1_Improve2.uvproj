# Keil uVision project Exp1_Improve2.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89E554RC SST
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) CLOCK(40000000)
  output: Exp1_Improve2
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Exp1_Improve2.asm
