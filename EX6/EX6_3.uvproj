# Keil uVision project EX6_3.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89E554RC SST
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) CLOCK(40000000)
  output: EX6_3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: EX6_DC_Control_Advanced.c
